# Repository jk1mly/pcb-ch340c

File README.md:

CH340Cを使ったシリアル／ダウンロード基板
USBシリアルを持たないマイコン基板などに使うための変換
電源は供給しない前提なので、汎用的に使うならM5Stackのダウンロードキットを買う方が良い

## KiCad design ch340g-dl.kicad_pcb

Parts:
C1: 0.1u; 0603
C2: 10u; CP_Radial_D5.0mm_P2.00mm
C3, C5: 0.1u; C_0603_1608Metric
C4: 10u; CP_Radial_D4.0mm_P1.50mm
D1: LED; LED_0603_1608Metric
F1: Fuse; Fuse_0603_1608Metric
IC1: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
J1: USB_B_Mini; USB_Mini_B_Female_aki
J2: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
Q1, Q2: SSM3K7002BFU; SOT-323_SC-70
R1: 0; R_0603_1608Metric
R2: NM; R_0603_1608Metric
R3: 1k; R_0603_1608Metric
R4: 2.2k; R_0603_1608Metric

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), IC1.1 (GND), J1.5 (GND), J1.6 (Shield), J2.6
unnamed: D1.2 (A), R3.2
unnamed: IC1.5 (UD+), J1.3 (D+)
unnamed: IC1.6 (UD-), J1.2 (D-)
unnamed: F1.2, J1.1 (VBUS)
unnamed: J2.1, R1.2, R2.2, R4.1
unnamed: IC1.3 (RXD), J2.2
unnamed: IC1.2 (TXD), J2.3, R4.2
unnamed: C5.1, J2.4, Q1.3 (D)
unnamed: J2.5, Q2.3 (D)
unnamed: IC1.13 (~DTR), Q1.2 (G), Q2.1 (S)
unnamed: IC1.14 (~RTS), Q1.1 (S), Q2.2 (G)
unnamed: C3.1, C4.1, IC1.4 (V3), R1.1
unnamed: C1.1, C2.1, F1.1, IC1.16 (VCC), R2.1, R3.1

Notes on the sheet:
VCC TXD RXD EN G0 GND
注意 ESP32プログラムダウンローダ M5StampのI/O配列相当

Board: 2 copper layers, 33.0 x 17.8 mm, 16 parts (0 on the bottom side), 14 nets.

## Commit log

2023-07-17 Add files via upload
    ファイル名がch340gだが使えるのは水晶が不要なch340cなので注意
